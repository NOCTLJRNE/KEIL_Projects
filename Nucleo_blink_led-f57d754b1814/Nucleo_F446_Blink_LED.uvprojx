# Keil uVision project Nucleo_F446_Blink_LED.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo_F446_Blink_LED
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;mbed;mbed/TARGET_NUCLEO_F446RE;mbed/TARGET_NUCLEO_F446RE/TARGET_STM;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F446RE;mbed/TARGET_NUCLEO_F446RE/TOOLCHAIN_ARM_MICRO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.cpp
    ./mbed/: gpio_api.c
software components: Device:STM32Cube HAL:GPIO 1.4.2, Device:Startup 2.4.2
